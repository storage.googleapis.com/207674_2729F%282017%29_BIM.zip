Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-06-07T17:20:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1645(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 07 17:20:31 2019 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{451A071C-5FA0-4F67-AA62-BEEDB683D097}\ifc * Database version: 5507 * Database creation date: Fri Jun 07 17:20:29 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 07 17:20:30 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 07 17:20:30 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 2729F Kitchen faucet with dishwasher valve, 230/5 V, 2729F(2017):2729F Kitchen faucet with dishwasher valve, 230/5 V:341494
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; NominalDepth: 248.808 mm; NominalHeight: 481.739 mm; NominalWidth: 122.235 mm; Projection: 200 mm
Type - Electrical(Type) - Electrical Connection: 230 / 5 V; Electronic Parts: Signal lights; Operating Voltage: 5 V
Type - General(Type) - Author: Convergo AB; BIMObjectName: 2729F(2017); ConvergoRefNr: 0087-1906-0044-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_45; Uniclass2015Description: Sink manual water supply sets; Uniclass2015Reference: Pr_40_20_87_82; Version: 1; VersionDate: 05/06/2019
Type - Green Building Properties(Type) - Customs Code: 84818011; EAN Number: 6414150079559; EMC Directive: 2014/30/EU; EN Standard: EN 15091; LVI Number: 6219129; Noise Class: I (ISO 3822) Oras lab.; NRF Number: 4200438; Protection Class: IP 54 / transformer IP 40; RSK Number: 8335468; VVS Number: 705658504
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/2729F; Catalog Drawing URL: http://static.oras.com/catdrw/2729F; Class: Two-handle, touchless, hybrid, plug transformer; Dimension Drawing URL: http://static.oras.com/dimdrw/2729F; FDV Document URL: http://www.oras.com/datasheet/2729F/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/2729F; Group: Kitchen faucets; Long Marketing: Kitchen faucet with easy-grip levers for hot and cold water, touchless function, temperature display with hot water warning, flexible high swivel spout, aerator and smart dishwasher valve. The flow-rate of hot and cold water is adjusted by separate levers. Spout’s swing angle is factory preset at 120° (can be limited to 60° or 80°). The touchless function is turned on by taking hands within the recognition range. The water temperature for the touchless function is adjusted by turning the ring between the faucet and the spout. Touchless function can be easily switched on/off. The dishwasher valve is opened by pressing a switch with signal light, and the valve closes automatically after preset period. Dishwasher valve closes automatically after 4 or 12 hours (one push opens the valve for 4 hours, pushing for 5 seconds opens the valve for 12 hours). Electrical connection with a plug transformer 230/5 V. The faucet is equipped with litter filters. F = with flexible pipes; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;DNK;POL;RUS;EST;LTU;LVA;UKR; Model: 2729F Kitchen faucet with dishwasher valve, 230/5 V; Name_en: 2729F Kitchen faucet with dishwasher valve, 230/5 V; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 1017 x 230 x 144; Package Weight: 4.927 kg; Product Code: 2729F; Product Datasheet: http://www.oras.com/datasheet/2729F/en; Product Family: Oras Optima; Product Image URL: http://static.oras.com/image/2729F; Product URL: http://static.oras.com/2729F; Type Name: 2729F Kitchen faucet with dishwasher valve, 230/5 V; Usage Group: Offices, personnel sanitary facilities;Institutional kitchens;Food industry;Gas stations;Schools;Households;Hotels, Restaurants, Café
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: DZR brass;Low lead <0.3;Waterways without nickel coating; Connection: Flexible Inlet Pipes; Connection Size: G3/8; Dishwasher Valve: Electronic dishwasher valve; Dishwasher Valve Open Period: 4 h / 12 h; Diverter: Integrated diverter / automatic reset; DN Size: DN15; Flow Rate At 300kPa: 0.00706293 m3/s; Hand Shower: Pull-out hand spray; Installation and Maintenance: http://static.oras.com/manual/2729F; Installation Type: Deck mounted; Lever Handle: Easy-Grip Lever; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 40; Mechanical Parts: Litter filter(s); Mounting Holes: 1 mounting hole; Pressure Loss With Flow 02ls: 300000 Pa; Shower Spray Number: 2Spray; Spare Parts: http://static.oras.com/sp/2729F; Spout Swivel Range: 120° (80° / 60°); Spout Type: Swivel spout
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Kitchen; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2729F(2017); Features: Two-handle, touchless, hybrid, plug transformer; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 2729F; Name: 2729F Kitchen faucet with dishwasher valve, 230/5 V; ReplacementCost: n/a; Shape: Sculptured; Size: 120x250x480 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 2729F; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 2729F Kitchen faucet with dishwasher valve, 230/5 V
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.210258 m2; Volume: 0.0146558 m3
Identity Data - Mark: 9
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 2729F(2017): 2729F Kitchen faucet with dishwasher valve, 230/5 V; Family and Type: 2729F(2017): 2729F Kitchen faucet with dishwasher valve, 230/5 V; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2729F(2017): 2729F Kitchen faucet with dishwasher valve, 230/5 V; Type Id: 2729F(2017): 2729F Kitchen faucet with dishwasher valve, 230/5 V; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
